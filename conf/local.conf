## conf/local.conf
```bitbake
[askAero]
SECREY_KEY='django-insecure-vs5869x9q^u=vt+2&5wj)i@81^=mo0j#qrpwk$)$s$asq_6$w_'
```
